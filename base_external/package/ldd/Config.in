## base_external/package/ldd/Config.in
```kconfig
config BR2_PACKAGE_LDD
	bool "ldd"
	help
	  Includes the skull and misc-modules in the kernel image for Assignment 7 part 2
```
